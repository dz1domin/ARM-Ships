# Keil uVision project lab1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab1
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LCD_ILI9325
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: TP_Open1768.c TP_Open1768.h asciiLib.c LCD_ILI9325.c Open1768_LCD.c asciiLib.h LCD_ILI9325.h Open1768_LCD.h interrupt_handler.c Game.c main.c Renderer.c Board.h Game.h Ship.h stack.c calibrate_lcd.h calibrate_lcd.c
software components: CMSIS:CORE 4.1.0, Board Support:Buttons 1.0.0, Board Support:Joystick 1.0.0, Board Support:LED 1.0.0, Device:GPIO 1.00, Device:PIN 1.00, Device:Startup 1.0.0
